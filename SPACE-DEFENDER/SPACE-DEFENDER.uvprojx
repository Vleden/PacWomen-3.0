# Keil uVision project SPACE-DEFENDER.uvprojx, settings and files
target SPACE-DEFENDER (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPACE-DEFENDER +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Headers\GAME;.\Headers\HARD;.\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Sources
    ./Sources/: main.c
    ./Sources/GAME/: menu.c game.c ImagesBMP.c random.c
    ./Sources/HARD/: GPIO.c TIMERS.c GLCD.c
  group Headers
    ./Headers/GAME/: ExtGlobales.h menu.h game.h ImagesBMP.h random.h
    ./Headers/HARD/: Registers.h GPIO.h TIMERS.h GLCD.h
  group Lib
    ./Lib/: Board_GLCD.h GLCD_Config.h GLCD_Fonts.c GLCD_MCBSTM32E.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
